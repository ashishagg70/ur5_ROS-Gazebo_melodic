Commit message: dynamic box

File: ur5_ROS-Gazebo/urdf/red_box.urdf (robot description, URDF)
Before this commit: robot red_box, 1 links, 0 joints
Links:
- link base_link: mass 0.005 -> 0.01
